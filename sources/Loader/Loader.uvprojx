# Keil uVision project Loader.uvprojx, settings and files
target Debug (6180000::V6.18::.\ARMCLANG537)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Loader-D
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: USE_HAL_DRIVER, GD32E230, DEBUG
  c include: .\src;.\src\Hardware\HAL;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x\Include;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x;..\common\GD32E23x_Firmware_Library\Firmware\GD32E23x_standard_peripheral\Include
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group GD32E23x
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Include/: gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Display
    ./src/Display/: Display7735.cpp Display7735.h Text.h
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font5.inc
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32e23x.s system_gd32e23x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: gd32e23x_it.cpp gd32e23x_it.h gd32e23x_libopt.h HAL.cpp HAL.h HAL_PINS.cpp HAL_PINS.h systick.cpp systick.h HAL_ROM.cpp
  group src
    ./src/: defines.h main.cpp stm_includes.h Upgrader.cpp Upgrader.h
  group Modules/LED
    ./src/Modules/LED/: driverLED.cpp driverLED.h LED.cpp LED.h
  group Modules/PAN3060
    ./src/Modules/PAN3060/: chirp_rf.cpp chirp_rf.h PAN3060.cpp PAN3060.h
  group Modules/ST7735
    ./src/Modules/ST7735/: ST7735.cpp ST7735.h
  group Utils
    ./src/Utils/: String.cpp String.h
target Release (6180000::V6.18::.\ARMCLANG537)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: Loader +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER, GD32E230
  c include: ..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x\Include;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x;.\src\Hardware\HAL;..\common\GD32E23x_Firmware_Library\Firmware\GD32E23x_standard_peripheral\Include;.\src
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2000
