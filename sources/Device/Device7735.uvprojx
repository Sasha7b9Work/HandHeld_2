# Keil uVision project Device7735.uvprojx, settings and files
target Debug (6180000::V6.18::.\ARMCLANG537)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: HandHeld7735Debug +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=6 v6Lto=1 wLevel=2
  c define: GD32E230, MODEL7735, DEBUG
  c include: ..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x\Include;.\src\Hardware\HAL;..\common\GD32E23x_Firmware_Library\Firmware\GD32E23x_standard_peripheral\Include;.\src;.\src\Hardware\HAL\GD23
  memory RVCT4: ROM 0x8002000 size 0xd800
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Device7735.sct
  group GD32E23x
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Include/: gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group src
    ./src/: defines.h main.cpp opt.h defines.cpp readme.txt
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h Vibrato.cpp Vibrato.h Power.cpp Power.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32e23x.s system_gd32e23x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: systick.h HAL_PINS.h HAL.h systick.cpp system.h HAL.cpp HAL_ADC.cpp
    ./src/Hardware/HAL/GD23/: HAL_CLOCK_23.cpp HAL_I2C_23.cpp HAL_PINS_23.cpp HAL_ROM_23.cpp gd32e23x_it.cpp gd32e23x_it.h gd32e23x_libopt.h
  group Display
    ./src/Display/: Colors.cpp Colors.h Icons.cpp Icons.h Text.h Display.h Display7735.cpp Display.cpp
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font5.inc font8.inc font10_7.inc
  group Keyboard
    ./src/Keyboard/: Keyboard.h Keyboard.cpp
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h Menu.txt MenuItemDef.h
  group Menu/Pages
    ./src/Menu/Pages/: Pages.h PageAlarm.cpp PageJournal.cpp PageWatch.cpp Pages.cpp
  group Modules/Beeper
    ./src/Modules/Beeper/: Beeper.cpp Beeper.h driverBeeper.h driverBeeper_23.cpp
  group Modules/Beeper/Sounds
    ./src/Modules/Beeper/Sounds/: sound1.h sound2.h sound3.h sound4.h sound5.h sound6.h sound7.h sound8.h sound9.h sound10.h
  group Modules/DriverST
    ./src/Modules/DriverST/: DriverST.h ST7735.cpp
  group Modules/LED
    ./src/Modules/LED/: driverLED.h LED.cpp LED.h driverLED_7735.cpp
  group Modules/PAN3060
    ./src/Modules/PAN3060/: PAN3060.cpp PAN3060.h chirp_rf.cpp chirp_rf.h
  group Modules/PCF8563
    ./src/Modules/PCF8563/: PCF8563.cpp PCF8563.h
  group Modules/PMS150G
    ./src/Modules/PMS150G/: PMS150G.cpp PMS150G.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h Source.cpp Source.h
    ./src/Utils/: GlobalFunctions.cpp GlobalFunctions.h
  group Storage
    ./src/Storage/: Storage.cpp Storage.h
  group Utils
    ./src/Utils/: Math.cpp Math.h FPS.cpp FPS.h StringUtils.cpp StringUtils.h
target Release (6180000::V6.18::.\ARMCLANG537)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: HandHeld7735 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=6 v6Lto=1 wLevel=2
  c define: GD32E230, MODEL7735
  c include: as above
  memory RVCT4: ROM 0x8002000 size 0xd800
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Device7735.sct
