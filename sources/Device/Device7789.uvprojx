# Keil uVision project Device7789.uvprojx, settings and files
target Debug (6180000::V6.18::.\ARMCLANG537)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HandHeld7789Debug +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=6 v6Lto=1 wLevel=2
  c define: GD32F30X_HD, MODEL7789, DEBUG
  c include: .\src;.\src\Hardware\HAL;..\common\GD32F30x_Firmware_Library\Firmware\CMSIS\GD\GD32F30x\Include;..\common\GD32F30x_Firmware_Library\Firmware\CMSIS;..\common\GD32F30x_Firmware_Library\Firmware\GD32F30x_standard_peripheral\Include;.\src\Hardware\HAL\GD303
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Device7789.sct
  group GD32E30x
    ../common/GD32F30x_Firmware_Library/Firmware/GD32F30x_standard_peripheral/Include/: gd32f30x_gpio.h gd32f30x_rcu.h
    ../common/GD32F30x_Firmware_Library/Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_exti.c gd32f30x_timer.c gd32f30x_adc.c gd32f30x_misc.c gd32f30x_fmc.c gd32f30x_spi.c
  group src
    ./src/: defines.h main.cpp defines.cpp readme.txt option.h
  group Hardware
    ./src/Hardware/: Timer.cpp Timer.h Vibrato.cpp Vibrato.h Power.cpp Power.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32f30x_hd.s system_gd32f30x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: systick.h HAL_PINS.h HAL.h systick.cpp system.h HAL.cpp HAL_ADC.cpp HAL_I2C.cpp HAL_PINS.cpp
    ./src/Hardware/HAL/GD303/: HAL_CLOCK_303.cpp gd32f30x_it.cpp HAL_ROM_303.cpp gd32f30x_it.h gd32f30x_libopt.h
  group Display
    ./src/Display/: Colors.cpp Colors.h Icons.cpp Icons.h Text.h Display.h Display.cpp
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font5.inc font8.inc font10_7.inc
  group Keyboard
    ./src/Keyboard/: Keyboard.h Keyboard.cpp
  group Menu
    ./src/Menu/: Menu.cpp Menu.h MenuItems.cpp MenuItems.h Menu.txt MenuItemDef.h
  group Menu/Pages
    ./src/Menu/Pages/: Pages.h PageAlarm.cpp PageJournal.cpp PageWatch.cpp Pages.cpp
  group Modules/Beeper
    ./src/Modules/Beeper/: Beeper.cpp Beeper.h driverBeeper.cpp
  group Modules/Beeper/Sounds
    ./src/Modules/Beeper/Sounds/: sound1.h sound2.h sound3.h sound4.h sound5.h sound6.h sound7.h sound8.h sound9.h sound10.h
  group Modules/LED
    ./src/Modules/LED/: driverLED.h LED.cpp LED.h driverLED_7735.cpp
  group Modules/PAN3060
    ./src/Modules/PAN3060/: PAN3060.cpp PAN3060.h chirp_rf.cpp chirp_rf.h
  group Modules/PCF8563
    ./src/Modules/PCF8563/: PCF8563.cpp PCF8563.h
  group Modules/PMS150G
    ./src/Modules/PMS150G/: PMS150G.cpp PMS150G.h
  group Modules/ST7735_89
    ./src/Modules/ST7735_89/: ST7735_89.cpp ST7735_89.h
  group Settings
    ./src/Settings/: Settings.cpp Settings.h Source.cpp Source.h
    ./src/Utils/: GlobalFunctions.cpp GlobalFunctions.h
  group Storage
    ./src/Storage/: Storage.cpp Storage.h
  group Utils
    ./src/Utils/: Math.cpp Math.h FPS.cpp FPS.h StringUtils.cpp StringUtils.h
target Release (6180000::V6.18::.\ARMCLANG537)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: as above
  output: HandHeld7789 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=6 v6Lto=1 wLevel=2
  c define: GD32F30X_HD, MODEL7789
  c include: .\src\Hardware\HAL;.\src;..\common\GD32F30x_Firmware_Library\Firmware\CMSIS\GD\GD32F30x\Include;..\common\GD32F30x_Firmware_Library\Firmware\CMSIS;..\common\GD32F30x_Firmware_Library\Firmware\GD32F30x_standard_peripheral\Include;.\src\Hardware\HAL\GD303
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\Device7789.sct
