<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>D:\My\Prog\GitHub\Work\HandHeld\HandHeld_2\sources\HandHeld_2.uvmpw</WorkspaceName>

  <project>
    <PathAndName>.\Device\Device7735.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\Device\Device7789.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

  <project>
    <PathAndName>.\Loader\Loader.uvprojx</PathAndName>
  </project>

  <project>
    <PathAndName>.\Transmitter\keil_v5\Transmitter.uvprojx</PathAndName>
  </project>

</ProjectWorkspace>
